# Keil uVision project STM32F10X_USB_HID.uvprojx, settings and files
target USB_HID (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F10X_USB_HID +hex
  c flags: OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\..\STM32F10X_USB_HID;..\Libraries\STM32_USB-FS-Device_Driver\inc;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\app_usb_lib\inc;..\Libraries\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STM32F10x_StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group STM32_USB-FS-Device_Driver
    ../Libraries/STM32_USB-FS-Device_Driver/inc/: usb_core.h usb_def.h usb_init.h usb_int.h usb_lib.h usb_mem.h usb_regs.h usb_sil.h usb_type.h
    ../Libraries/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group CMSIS
    ../Libraries/CMSIS/Include/: arm_common_tables.h arm_math.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h core_sc000.h core_sc300.h
  group USER
    ../: hw_config.c hw_config.h main.c platform_config.h startup_stm32f10x_md_vl.s stm32_it.c stm32_it.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group USB_LIB
    ../app_usb_lib/inc/: usb_conf.h usb_desc.h usb_istr.h usb_prop.h usb_pwr.h
    ../app_usb_lib/src/: usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
